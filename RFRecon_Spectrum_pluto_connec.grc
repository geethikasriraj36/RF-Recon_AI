options:
  parameters:
    generate_options: qt_gui
    id: RFRecon_Spectrum
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 700e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1024'
    max_iter: '4000'
    scale: 1/1024
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Frequency Extractor",
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))

              self.set_msg_handler(
                  pmt.intern("in"),
                  self.handle_msg
              )

          def handle_msg(self, msg):
              try:
                  data = pmt.to_python(msg)

                  print("Received:", data)

                  if isinstance(data, np.ndarray):
                      values = data.flatten()
                  elif isinstance(data, (list, tuple)):
                      values = np.asarray(data).flatten()
                  else:
                      values = np.asarray([data]).flatten()

                  if len(values) > 0:
                      frequency_hz = float(values[0])
                      frequency_mhz = frequency_hz / 1000000.0

                      print("Detected Frequency (Hz):", frequency_hz)
                      print("Detected Frequency (MHz):", frequency_mhz)

                      self.message_port_pub(
                          pmt.intern("out"),
                          pmt.from_double(frequency_mhz)
                      )

              except Exception as e:
                  print("Frequency extractor error:", e)
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400000000'
    gain1: '''hybrid'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '20000000'
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: inspector_signal_detector_cvf_0
  id: inspector_signal_detector_cvf
  parameters:
    auto: 'False'
    avg: '0.8'
    fft_len: '4096'
    logfile: ''
    min_bw: '0'
    quant: '0.0001'
    samp_rate: samp_rate
    sensitivity: '0.5'
    threshold: '-60'
    window: window.WIN_BLACKMAN_hARRIS
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 700e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 200e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: Detected Frequency
    type: float
    value: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    avg: '0.1'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Signal Power (dB)"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    name: '"Time Domain"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    vlen: '4096'
    x_axis_label: '"Frequency"'
    x_start: '-1'
    x_step: '0.00048828125'
    x_units: '"MHz"'
    y_axis_label: '"Relative Gain"'
    y_units: '"dB"'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0, out, blocks_message_debug_1, print]
- [epy_block_0, out, qtgui_edit_box_msg_0, val]
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [inspector_signal_detector_cvf_0, '0', qtgui_vector_sink_f_0, '0']
- [inspector_signal_detector_cvf_0, map_out, blocks_message_debug_0, print]
- [inspector_signal_detector_cvf_0, map_out, epy_block_0, in]
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0, '0', inspector_signal_detector_cvf_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
